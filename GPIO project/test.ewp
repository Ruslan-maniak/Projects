# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; Config\; SPL\inc\; Source\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test.hex
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group Config
    Config/: startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group Source
    Source/GPIO/: GPIO.c
  group SPL
    SPL/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c
